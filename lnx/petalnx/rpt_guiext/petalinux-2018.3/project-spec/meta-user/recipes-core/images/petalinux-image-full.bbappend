#Note: Mention Each package in individual line
#      cascaded representation with line breaks are not valid in this file.
IMAGE_INSTALL_append = " resolvconf"
IMAGE_INSTALL_append = " libiio"
IMAGE_INSTALL_append = " libiio-iiod"
IMAGE_INSTALL_append = " libiio-tests"
IMAGE_INSTALL_append = " ntp"
IMAGE_INSTALL_append = " iperf3"
IMAGE_INSTALL_append = " ethtool"
IMAGE_INSTALL_append = " dirstruct"
IMAGE_INSTALL_append = " sys-init"
