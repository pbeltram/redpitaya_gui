#
# Default timezone is Ljubljana/Slovenia
#

DEFAULT_TIMEZONE = "Europe/Ljubljana"

