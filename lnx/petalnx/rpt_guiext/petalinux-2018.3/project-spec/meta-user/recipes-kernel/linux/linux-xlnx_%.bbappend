SRC_URI += "file://bsp.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

#KERNEL_VERSION_SANITY_SKIP="1"
